Commit message: added camera

File: assets/camera.urdf (robot description, URDF)
Before this commit: robot camera, 2 links, 1 joints
Links:
- link baseLink: geometry visual box size=0.02 0.01 0.04
- link camera_frame: geometry visual cylinder length=0.001 radius=0.005
